# Keil uVision project ctxtswitch.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C1236H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ctxtswitch
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: serial.c timer.c main.c staticMalloc.c scheduler.c lists.c semaphore.c semaphore.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.1
